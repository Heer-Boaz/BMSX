# Repository Heer-Boaz/BMSX (continued)

## KiCad design hardware/ecad/mainboard_memory_candidate/BMSX.kicad_pcb (continued)

Schematic: asic_u4.kicad_sch, BMSX APU

Parts:
U4: BMSX APU; U4

Connections:
ARAM_A0: U4.80 (ARAM_A0); also elsewhere on the board
ARAM_A1: U4.79 (ARAM_A1); also elsewhere on the board
ARAM_A2: U4.78 (ARAM_A2); also elsewhere on the board
ARAM_A3: U4.77 (ARAM_A3); also elsewhere on the board
ARAM_A4: U4.76 (ARAM_A4); also elsewhere on the board
ARAM_A5: U4.75 (ARAM_A5); also elsewhere on the board
ARAM_A6: U4.74 (ARAM_A6); also elsewhere on the board
ARAM_A7: U4.73 (ARAM_A7); also elsewhere on the board
ARAM_A8: U4.72 (ARAM_A8); also elsewhere on the board
ARAM_A9: U4.71 (ARAM_A9); also elsewhere on the board
ARAM_A10: U4.70 (ARAM_A10); also elsewhere on the board
ARAM_A11: U4.69 (ARAM_A11); also elsewhere on the board
ARAM_A12: U4.68 (ARAM_A12); also elsewhere on the board
ARAM_A13: U4.67 (ARAM_A13); also elsewhere on the board
ARAM_A14: U4.41 (ARAM_A14); also elsewhere on the board
ARAM_A15: U4.42 (ARAM_A15); also elsewhere on the board
ARAM_A16: U4.43 (ARAM_A16); also elsewhere on the board
ARAM_A17: U4.44 (ARAM_A17); also elsewhere on the board
ARAM_BE0_N: U4.45 (ARAM_BE0_N); also elsewhere on the board
ARAM_BE1_N: U4.46 (ARAM_BE1_N); also elsewhere on the board
ARAM_CE_N: U4.49 (ARAM_CE_N); also elsewhere on the board
ARAM_D0: U4.100 (ARAM_D0); also elsewhere on the board
ARAM_D1: U4.99 (ARAM_D1); also elsewhere on the board
ARAM_D2: U4.98 (ARAM_D2); also elsewhere on the board
ARAM_D3: U4.97 (ARAM_D3); also elsewhere on the board
ARAM_D4: U4.96 (ARAM_D4); also elsewhere on the board
ARAM_D5: U4.95 (ARAM_D5); also elsewhere on the board
ARAM_D6: U4.92 (ARAM_D6); also elsewhere on the board
ARAM_D7: U4.91 (ARAM_D7); also elsewhere on the board
ARAM_D8: U4.90 (ARAM_D8); also elsewhere on the board
ARAM_D9: U4.89 (ARAM_D9); also elsewhere on the board
ARAM_D10: U4.88 (ARAM_D10); also elsewhere on the board
ARAM_D11: U4.87 (ARAM_D11); also elsewhere on the board
ARAM_D12: U4.84 (ARAM_D12); also elsewhere on the board
ARAM_D13: U4.83 (ARAM_D13); also elsewhere on the board
ARAM_D14: U4.82 (ARAM_D14); also elsewhere on the board
ARAM_D15: U4.81 (ARAM_D15); also elsewhere on the board
ARAM_OE_N: U4.50 (ARAM_OE_N); also elsewhere on the board
ARAM_WE_N: U4.51 (ARAM_WE_N); also elsewhere on the board
AUD_BCLK: U4.52 (AUD_BCLK); also elsewhere on the board
AUD_DATA: U4.53 (AUD_DATA); also elsewhere on the board
AUD_LRCK: U4.54 (AUD_LRCK); also elsewhere on the board
AUD_MCLK: U4.57 (AUD_MCLK); also elsewhere on the board
CLK_APU: U4.106 (CLK_SYS); also elsewhere on the board
CS_APU_N: U4.114 (CS_APU_N); also elsewhere on the board
DREQ_APU_R: U4.107 (DREQ_APU_R); also elsewhere on the board
DREQ_APU_W: U4.108 (DREQ_APU_W); also elsewhere on the board
GND: U4.1 (GND), U4.9 (GND), U4.17 (GND), U4.37 (GND), U4.39 (GND), U4.47 (GND), U4.55 (GND), U4.63 (GND), U4.66 (GND), U4.86 (GND), U4.94 (GND), U4.102 (GND), U4.104 (GND), U4.112 (GND), U4.120 (GND), U4.128 (GND); also elsewhere on the board
GNT_APU: U4.110 (GNT_APU); also elsewhere on the board
IRQ_APU_N: U4.109 (IRQ_APU_N); also elsewhere on the board
JTAG_APU_IO: U4.58 (TDO); also elsewhere on the board
JTAG_GFX_APU: U4.59 (TDI); also elsewhere on the board
REQ_APU: U4.113 (REQ_APU); also elsewhere on the board
RESET_N: U4.105 (RESET_N); also elsewhere on the board
SYS_AD0: U4.3 (SYS_AD0); also elsewhere on the board
SYS_AD1: U4.4 (SYS_AD1); also elsewhere on the board
SYS_AD2: U4.5 (SYS_AD2); also elsewhere on the board
SYS_AD3: U4.6 (SYS_AD3); also elsewhere on the board
SYS_AD4: U4.7 (SYS_AD4); also elsewhere on the board
SYS_AD5: U4.8 (SYS_AD5); also elsewhere on the board
SYS_AD6: U4.11 (SYS_AD6); also elsewhere on the board
SYS_AD7: U4.12 (SYS_AD7); also elsewhere on the board
SYS_AD8: U4.13 (SYS_AD8); also elsewhere on the board
SYS_AD9: U4.14 (SYS_AD9); also elsewhere on the board
SYS_AD10: U4.15 (SYS_AD10); also elsewhere on the board
SYS_AD11: U4.16 (SYS_AD11); also elsewhere on the board
SYS_AD12: U4.19 (SYS_AD12); also elsewhere on the board
SYS_AD13: U4.20 (SYS_AD13); also elsewhere on the board
SYS_AD14: U4.21 (SYS_AD14); also elsewhere on the board
SYS_AD15: U4.22 (SYS_AD15); also elsewhere on the board
SYS_AD16: U4.23 (SYS_AD16); also elsewhere on the board
SYS_AD17: U4.24 (SYS_AD17); also elsewhere on the board
SYS_AD18: U4.25 (SYS_AD18); also elsewhere on the board
SYS_AD19: U4.26 (SYS_AD19); also elsewhere on the board
SYS_AD20: U4.27 (SYS_AD20); also elsewhere on the board
SYS_AD21: U4.28 (SYS_AD21); also elsewhere on the board
SYS_AD22: U4.29 (SYS_AD22); also elsewhere on the board
SYS_AD23: U4.30 (SYS_AD23); also elsewhere on the board
SYS_AD24: U4.31 (SYS_AD24); also elsewhere on the board
SYS_AD25: U4.32 (SYS_AD25); also elsewhere on the board
SYS_AD26: U4.33 (SYS_AD26); also elsewhere on the board
SYS_AD27: U4.34 (SYS_AD27); also elsewhere on the board
SYS_AD28: U4.35 (SYS_AD28); also elsewhere on the board
SYS_AD29: U4.36 (SYS_AD29); also elsewhere on the board
SYS_AD30: U4.126 (SYS_AD30); also elsewhere on the board
SYS_AD31: U4.125 (SYS_AD31); also elsewhere on the board
SYS_AS_N: U4.124 (SYS_AS_N); also elsewhere on the board
SYS_BE0_N: U4.121 (SYS_BE0_N); also elsewhere on the board
SYS_BE1_N: U4.118 (SYS_BE1_N); also elsewhere on the board
SYS_BE2_N: U4.117 (SYS_BE2_N); also elsewhere on the board
SYS_BE3_N: U4.116 (SYS_BE3_N); also elsewhere on the board
SYS_RD_N: U4.123 (SYS_RD_N); also elsewhere on the board
SYS_READY_N: U4.115 (SYS_READY_N); also elsewhere on the board
SYS_WR_N: U4.122 (SYS_WR_N); also elsewhere on the board
TCK: U4.60 (TCK); also elsewhere on the board
TMS: U4.61 (TMS); also elsewhere on the board
TRST_N: U4.62 (TRST_N); also elsewhere on the board
V3V3: U4.2 (VDD), U4.10 (VDD), U4.18 (VDD), U4.38 (VDD), U4.40 (VDD), U4.48 (VDD), U4.56 (VDD), U4.64 (VDD), U4.65 (VDD), U4.85 (VDD), U4.93 (VDD), U4.101 (VDD), U4.103 (VDD), U4.111 (VDD), U4.119 (VDD), U4.127 (VDD); also elsewhere on the board

Notes on the sheet:
Four-package ECO. External signal directions retained; GEO/IMGDEC and GPU/PCRTC links are internalized. SYS32 remains multicycle. Package power and TAP require ASIC implementation and BSDL qualification.
POWER
SYS32
AUDIO SRAM
AUDIO OUTPUT
CONTROL AND TAP

Schematic: asic_u7.kicad_sch, BMSX IO + ROM bridge

Parts:
U7: BMSX IO + ROM bridge; U7

Connections:
CLK_IO: U7.41 (CLK_SYS); also elsewhere on the board
CS_IO_N: U7.42 (CS_IO_N); also elsewhere on the board
CS_ROM_N: U7.110 (CS_ROM_N); also elsewhere on the board
DISPLAY_CONTEXT: U7.62 (DISPLAY_CONTEXT); also elsewhere on the board
GND: U7.1 (GND), U7.19 (GND), U7.37 (GND), U7.39 (GND), U7.63 (GND), U7.66 (GND), U7.84 (GND), U7.102 (GND), U7.104 (GND), U7.128 (GND); also elsewhere on the board
JTAG_APU_IO: U7.106 (TDI); also elsewhere on the board
PAD_CLK: U7.43 (PAD_CLK); also elsewhere on the board
PAD_CMD0: U7.44 (PAD_CMD0); also elsewhere on the board
PAD_CMD1: U7.45 (PAD_CMD1); also elsewhere on the board
PAD_CMD2: U7.46 (PAD_CMD2); also elsewhere on the board
PAD_CMD3: U7.47 (PAD_CMD3); also elsewhere on the board
PAD_DATA0: U7.48 (PAD_DATA0); also elsewhere on the board
PAD_DATA1: U7.49 (PAD_DATA1); also elsewhere on the board
PAD_DATA2: U7.50 (PAD_DATA2); also elsewhere on the board
PAD_DATA3: U7.51 (PAD_DATA3); also elsewhere on the board
PAD_SELECT0_N: U7.52 (PAD_SELECT0_N); also elsewhere on the board
PAD_SELECT1_N: U7.53 (PAD_SELECT1_N); also elsewhere on the board
PAD_SELECT2_N: U7.54 (PAD_SELECT2_N); also elsewhere on the board
PAD_SELECT3_N: U7.55 (PAD_SELECT3_N); also elsewhere on the board
PS2_KBD_CLK: U7.56 (PS2_KBD_CLK); also elsewhere on the board
PS2_KBD_DATA: U7.57 (PS2_KBD_DATA); also elsewhere on the board
RESET_N: U7.58 (RESET_N); also elsewhere on the board
ROM_A0: U7.21 (ROM_A0); also elsewhere on the board
ROM_A1: U7.22 (ROM_A1); also elsewhere on the board
ROM_A2: U7.23 (ROM_A2); also elsewhere on the board
ROM_A3: U7.24 (ROM_A3); also elsewhere on the board
ROM_A4: U7.25 (ROM_A4); also elsewhere on the board
ROM_A5: U7.26 (ROM_A5); also elsewhere on the board
ROM_A6: U7.27 (ROM_A6); also elsewhere on the board
ROM_A7: U7.28 (ROM_A7); also elsewhere on the board
ROM_A8: U7.29 (ROM_A8); also elsewhere on the board
ROM_A9: U7.30 (ROM_A9); also elsewhere on the board
ROM_A10: U7.31 (ROM_A10); also elsewhere on the board
ROM_A11: U7.32 (ROM_A11); also elsewhere on the board
ROM_A12: U7.33 (ROM_A12); also elsewhere on the board
ROM_A13: U7.34 (ROM_A13); also elsewhere on the board
ROM_A14: U7.35 (ROM_A14); also elsewhere on the board
ROM_A15: U7.36 (ROM_A15); also elsewhere on the board
ROM_A16: U7.126 (ROM_A16); also elsewhere on the board
ROM_A17: U7.125 (ROM_A17); also elsewhere on the board
ROM_A18: U7.124 (ROM_A18); also elsewhere on the board
ROM_A19: U7.123 (ROM_A19); also elsewhere on the board
ROM_A20: U7.122 (ROM_A20); also elsewhere on the board
ROM_A21: U7.121 (ROM_A21); also elsewhere on the board
ROM_CE_N: U7.120 (ROM_CE_N); also elsewhere on the board
ROM_D0: U7.3 (ROM_D0); also elsewhere on the board
ROM_D1: U7.4 (ROM_D1); also elsewhere on the board
ROM_D2: U7.5 (ROM_D2); also elsewhere on the board
ROM_D3: U7.6 (ROM_D3); also elsewhere on the board
ROM_D4: U7.7 (ROM_D4); also elsewhere on the board
ROM_D5: U7.8 (ROM_D5); also elsewhere on the board
ROM_D6: U7.9 (ROM_D6); also elsewhere on the board
ROM_D7: U7.10 (ROM_D7); also elsewhere on the board
ROM_D8: U7.11 (ROM_D8); also elsewhere on the board
ROM_D9: U7.12 (ROM_D9); also elsewhere on the board
ROM_D10: U7.13 (ROM_D10); also elsewhere on the board
ROM_D11: U7.14 (ROM_D11); also elsewhere on the board
ROM_D12: U7.15 (ROM_D12); also elsewhere on the board
ROM_D13: U7.16 (ROM_D13); also elsewhere on the board
ROM_D14: U7.17 (ROM_D14); also elsewhere on the board
ROM_D15: U7.18 (ROM_D15); also elsewhere on the board
ROM_OE_N: U7.119 (ROM_OE_N); also elsewhere on the board
SUPERVISOR_N: U7.59 (SUPERVISOR_N); also elsewhere on the board
SUPERVISOR_RAW_N: U7.60 (SUPERVISOR_RAW_N); also elsewhere on the board
SYS_AD0: U7.100 (SYS_AD0); also elsewhere on the board
SYS_AD1: U7.99 (SYS_AD1); also elsewhere on the board
SYS_AD2: U7.98 (SYS_AD2); also elsewhere on the board
SYS_AD3: U7.97 (SYS_AD3); also elsewhere on the board
SYS_AD4: U7.96 (SYS_AD4); also elsewhere on the board
SYS_AD5: U7.95 (SYS_AD5); also elsewhere on the board
SYS_AD6: U7.94 (SYS_AD6); also elsewhere on the board
SYS_AD7: U7.93 (SYS_AD7); also elsewhere on the board
SYS_AD8: U7.92 (SYS_AD8); also elsewhere on the board
SYS_AD9: U7.91 (SYS_AD9); also elsewhere on the board
SYS_AD10: U7.90 (SYS_AD10); also elsewhere on the board
SYS_AD11: U7.89 (SYS_AD11); also elsewhere on the board
SYS_AD12: U7.88 (SYS_AD12); also elsewhere on the board
SYS_AD13: U7.87 (SYS_AD13); also elsewhere on the board
SYS_AD14: U7.86 (SYS_AD14); also elsewhere on the board
SYS_AD15: U7.85 (SYS_AD15); also elsewhere on the board
SYS_AD16: U7.82 (SYS_AD16); also elsewhere on the board
SYS_AD17: U7.81 (SYS_AD17); also elsewhere on the board
SYS_AD18: U7.80 (SYS_AD18); also elsewhere on the board
SYS_AD19: U7.79 (SYS_AD19); also elsewhere on the board
SYS_AD20: U7.78 (SYS_AD20); also elsewhere on the board
SYS_AD21: U7.77 (SYS_AD21); also elsewhere on the board
SYS_AD22: U7.76 (SYS_AD22); also elsewhere on the board
SYS_AD23: U7.75 (SYS_AD23); also elsewhere on the board
SYS_AD24: U7.74 (SYS_AD24); also elsewhere on the board
SYS_AD25: U7.73 (SYS_AD25); also elsewhere on the board
SYS_AD26: U7.72 (SYS_AD26); also elsewhere on the board
SYS_AD27: U7.71 (SYS_AD27); also elsewhere on the board
SYS_AD28: U7.70 (SYS_AD28); also elsewhere on the board
SYS_AD29: U7.69 (SYS_AD29); also elsewhere on the board
SYS_AD30: U7.68 (SYS_AD30); also elsewhere on the board
SYS_AD31: U7.67 (SYS_AD31); also elsewhere on the board
SYS_AS_N: U7.118 (SYS_AS_N); also elsewhere on the board
SYS_BE0_N: U7.115 (SYS_BE0_N); also elsewhere on the board
SYS_BE1_N: U7.114 (SYS_BE1_N); also elsewhere on the board
SYS_BE2_N: U7.113 (SYS_BE2_N); also elsewhere on the board
SYS_BE3_N: U7.112 (SYS_BE3_N); also elsewhere on the board
SYS_RD_N: U7.117 (SYS_RD_N); also elsewhere on the board
SYS_READY_N: U7.111 (SYS_READY_N); also elsewhere on the board
SYS_WR_N: U7.116 (SYS_WR_N); also elsewhere on the board
TCK: U7.109 (TCK); also elsewhere on the board
TDO_RETURN: U7.105 (TDO); also elsewhere on the board
TMS: U7.108 (TMS); also elsewhere on the board
TRST_N: U7.107 (TRST_N); also elsewhere on the board
V3V3: U7.2 (VDD), U7.20 (VDD), U7.38 (VDD), U7.40 (VDD), U7.64 (VDD), U7.65 (VDD), U7.83 (VDD), U7.101 (VDD), U7.103 (VDD), U7.127 (VDD); also elsewhere on the board
VBLANK_EVT: U7.61 (VBLANK_EVT); also elsewhere on the board

Notes on the sheet:
Four-package ECO. External signal directions retained; GEO/IMGDEC and GPU/PCRTC links are internalized. SYS32 remains multicycle. Package power and TAP require ASIC implementation and BSDL qualification.
POWER
FIRMWARE ROM
CONTROL AND TAP
PERIPHERALS
SYS32

Schematic: private_memory.kicad_sch, Main DRAM and support

Parts:
C600: 100nF 16V X7R 0805; C210
C601: 100nF 16V X7R 0805; C211
C602: 100nF 16V X7R 0805; C212
C603: 100nF 16V X7R 0805; C213
C604: 100nF 16V X7R 0805; C214
C605: 100nF 16V X7R 0805; C215
U150: IS41LV16100-50KI [2005 reference]; U10
U151: IS41LV16100-50KI [2005 reference]; U11

Connections:
GND: C600.2 (GND), C601.2 (GND), C602.2 (GND), C603.2 (GND), C604.2 (GND), C605.2 (GND), U150.22 (GND), U150.37 (GND), U150.42 (GND), U151.22 (GND), U151.37 (GND), U151.42 (GND); also elsewhere on the board
MA0: U150.17 (A0), U151.17 (A0); also elsewhere on the board
MA1: U150.18 (A1), U151.18 (A1); also elsewhere on the board
MA2: U150.19 (A2), U151.19 (A2); also elsewhere on the board
MA3: U150.20 (A3), U151.20 (A3); also elsewhere on the board
MA4: U150.23 (A4), U151.23 (A4); also elsewhere on the board
MA5: U150.24 (A5), U151.24 (A5); also elsewhere on the board
MA6: U150.25 (A6), U151.25 (A6); also elsewhere on the board
MA7: U150.26 (A7), U151.26 (A7); also elsewhere on the board
MA8: U150.27 (A8), U151.27 (A8); also elsewhere on the board
MA9: U150.28 (A9), U151.28 (A9); also elsewhere on the board
MCAS0_N: U150.31 (LCAS_N); also elsewhere on the board
MCAS1_N: U150.30 (UCAS_N); also elsewhere on the board
MCAS2_N: U151.31 (LCAS_N); also elsewhere on the board
MCAS3_N: U151.30 (UCAS_N); also elsewhere on the board
MD0: U150.2 (DQ0); also elsewhere on the board
MD1: U150.3 (DQ1); also elsewhere on the board
MD2: U150.4 (DQ2); also elsewhere on the board
MD3: U150.5 (DQ3); also elsewhere on the board
MD4: U150.7 (DQ4); also elsewhere on the board
MD5: U150.8 (DQ5); also elsewhere on the board
MD6: U150.9 (DQ6); also elsewhere on the board
MD7: U150.10 (DQ7); also elsewhere on the board
MD8: U150.33 (DQ8); also elsewhere on the board
MD9: U150.34 (DQ9); also elsewhere on the board
MD10: U150.35 (DQ10); also elsewhere on the board
MD11: U150.36 (DQ11); also elsewhere on the board
MD12: U150.38 (DQ12); also elsewhere on the board
MD13: U150.39 (DQ13); also elsewhere on the board
MD14: U150.40 (DQ14); also elsewhere on the board
MD15: U150.41 (DQ15); also elsewhere on the board
MD16: U151.2 (DQ0); also elsewhere on the board
MD17: U151.3 (DQ1); also elsewhere on the board
MD18: U151.4 (DQ2); also elsewhere on the board
MD19: U151.5 (DQ3); also elsewhere on the board
MD20: U151.7 (DQ4); also elsewhere on the board
MD21: U151.8 (DQ5); also elsewhere on the board
MD22: U151.9 (DQ6); also elsewhere on the board
MD23: U151.10 (DQ7); also elsewhere on the board
MD24: U151.33 (DQ8); also elsewhere on the board
MD25: U151.34 (DQ9); also elsewhere on the board
MD26: U151.35 (DQ10); also elsewhere on the board
MD27: U151.36 (DQ11); also elsewhere on the board
MD28: U151.38 (DQ12); also elsewhere on the board
MD29: U151.39 (DQ13); also elsewhere on the board
MD30: U151.40 (DQ14); also elsewhere on the board
MD31: U151.41 (DQ15); also elsewhere on the board
MOE_PRIVATE_N: U150.29 (OE_N), U151.29 (OE_N); also elsewhere on the board
MRAS_PRIVATE_N: U150.14 (RAS_N), U151.14 (RAS_N); also elsewhere on the board
MWE_N: U150.13 (WE_N), U151.13 (WE_N); also elsewhere on the board
V3V3: C600.1 (V3V3), C601.1 (V3V3), C602.1 (V3V3), C603.1 (V3V3), C604.1 (V3V3), C605.1 (V3V3), U150.1 (VDD), U150.6 (VDD), U150.21 (VDD), U151.1 (VDD), U151.6 (VDD), U151.21 (VDD); also elsewhere on the board

Notes on the sheet:
Candidate private DRAM; shared data and address, separate RAS and OE.

Schematic: snapshot_memory.kicad_sch, R9 external local SRAM and read-only firmware flash

Parts:
U152: IS61WV51216BLL-10TLI; U30
U153: IS61WV51216BLL-10TLI; U31

Connections:
GND: U152.12 (GND), U152.34 (GND), U153.12 (GND), U153.34 (GND); also elsewhere on the board
SNAPSHOT_CE_N: U152.6 (CE_N), U153.6 (CE_N); also elsewhere on the board
V3V3: U152.11 (VDD), U152.33 (VDD), U153.11 (VDD), U153.33 (VDD); also elsewhere on the board
VRAM_A0: U152.1 (A0), U153.1 (A0); also elsewhere on the board
VRAM_A1: U152.2 (A1), U153.2 (A1); also elsewhere on the board
VRAM_A2: U152.3 (A2), U153.3 (A2); also elsewhere on the board
VRAM_A3: U152.4 (A3), U153.4 (A3); also elsewhere on the board
VRAM_A4: U152.5 (A4), U153.5 (A4); also elsewhere on the board
VRAM_A5: U152.18 (A5), U153.18 (A5); also elsewhere on the board
VRAM_A6: U152.19 (A6), U153.19 (A6); also elsewhere on the board
VRAM_A7: U152.20 (A7), U153.20 (A7); also elsewhere on the board
VRAM_A8: U152.21 (A8), U153.21 (A8); also elsewhere on the board
VRAM_A9: U152.22 (A9), U153.22 (A9); also elsewhere on the board
VRAM_A10: U152.23 (A10), U153.23 (A10); also elsewhere on the board
VRAM_A11: U152.24 (A11), U153.24 (A11); also elsewhere on the board
VRAM_A12: U152.25 (A12), U153.25 (A12); also elsewhere on the board
VRAM_A13: U152.26 (A13), U153.26 (A13); also elsewhere on the board
VRAM_A14: U152.27 (A14), U153.27 (A14); also elsewhere on the board
VRAM_A15: U152.42 (A15), U153.42 (A15); also elsewhere on the board
VRAM_A16: U152.43 (A16), U153.43 (A16); also elsewhere on the board
VRAM_A17: U152.44 (A17), U153.44 (A17); also elsewhere on the board
VRAM_A18: U152.28 (A18), U153.28 (A18); also elsewhere on the board
VRAM_BE0_N: U152.39 (LB_N); also elsewhere on the board
VRAM_BE1_N: U152.40 (UB_N); also elsewhere on the board
VRAM_BE2_N: U153.39 (LB_N); also elsewhere on the board
VRAM_BE3_N: U153.40 (UB_N); also elsewhere on the board
VRAM_D0: U152.7 (D0); also elsewhere on the board
VRAM_D1: U152.8 (D1); also elsewhere on the board
VRAM_D2: U152.9 (D2); also elsewhere on the board
VRAM_D3: U152.10 (D3); also elsewhere on the board
VRAM_D4: U152.13 (D4); also elsewhere on the board
VRAM_D5: U152.14 (D5); also elsewhere on the board
VRAM_D6: U152.15 (D6); also elsewhere on the board
VRAM_D7: U152.16 (D7); also elsewhere on the board
VRAM_D8: U152.29 (D8); also elsewhere on the board
VRAM_D9: U152.30 (D9); also elsewhere on the board
VRAM_D10: U152.31 (D10); also elsewhere on the board
VRAM_D11: U152.32 (D11); also elsewhere on the board
VRAM_D12: U152.35 (D12); also elsewhere on the board
VRAM_D13: U152.36 (D13); also elsewhere on the board
VRAM_D14: U152.37 (D14); also elsewhere on the board
VRAM_D15: U152.38 (D15); also elsewhere on the board
VRAM_D16: U153.7 (D0); also elsewhere on the board
VRAM_D17: U153.8 (D1); also elsewhere on the board
VRAM_D18: U153.9 (D2); also elsewhere on the board
VRAM_D19: U153.10 (D3); also elsewhere on the board
VRAM_D20: U153.13 (D4); also elsewhere on the board
VRAM_D21: U153.14 (D5); also elsewhere on the board
VRAM_D22: U153.15 (D6); also elsewhere on the board
VRAM_D23: U153.16 (D7); also elsewhere on the board
VRAM_D24: U153.29 (D8); also elsewhere on the board
VRAM_D25: U153.30 (D9); also elsewhere on the board
VRAM_D26: U153.31 (D10); also elsewhere on the board
VRAM_D27: U153.32 (D11); also elsewhere on the board
VRAM_D28: U153.35 (D12); also elsewhere on the board
VRAM_D29: U153.36 (D13); also elsewhere on the board
VRAM_D30: U153.37 (D14); also elsewhere on the board
VRAM_D31: U153.38 (D15); also elsewhere on the board
VRAM_OE_N: U152.41 (OE_N), U153.41 (OE_N); also elsewhere on the board
VRAM_WE_N: U152.17 (WE_N), U153.17 (WE_N); also elsewhere on the board

Schematic: snapshot_memory_support.kicad_sch, R9 memory bypass and default deselect

Parts:
C610: 100nF 16V X7R; C500
C611: 100nF 16V X7R; C501
C612: 1uF 16V X7R; C502
C613: 100nF 16V X7R; C503
C614: 100nF 16V X7R; C504
C615: 1uF 16V X7R; C505
R600: 10k 1%; R500

Connections:
GND: C610.2, C611.2, C612.2, C613.2, C614.2, C615.2; also elsewhere on the board
SNAPSHOT_CE_N: R600.1; also elsewhere on the board
V3V3: C610.1, C611.1, C612.1, C613.1, C614.1, C615.1, R600.2; also elsewhere on the board

Board: 8 copper layers, 358 parts (140 on the bottom side), 452 nets, no tracks yet.

Other parts of the board:
H1: H1
H2: H2
H3: H3
H4: H4
H5: H5
H6: H6
H7: H7
H8: H8
H9: H9
H10: H10
H11: H11
H12: H12
H13: H13
H14: H14
H15: H15
H_CTRL1: H_CTRL1
H_CTRL2: H_CTRL2
