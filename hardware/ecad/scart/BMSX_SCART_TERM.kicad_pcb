# Repository Heer-Boaz/BMSX (continued)

## KiCad design hardware/ecad/mainboard_memory_candidate/BMSX.kicad_pcb (continued)

Schematic: av_harness.kicad_sch, R9 SCART harness and RGB current termination

Parts:
C533: 18pF 5% C0G 50V; C_0805_2012Metric; MPN C0805C180J5GACTU
C534: 100nF 10% X7R 25V; CL10B104KA8NNNC_retained_0603; MPN CL10B104KA8NNNC
C535: 22uF 10% X5R 10V; CL31A226KPHNNNE_1206; MPN CL31A226KPHNNNE
J500: 61201621621; Wurth_61201621621_2x08_P2.54mm_Vertical; MPN 61201621621
R525: 75R 0.1%; R525
R526: 75R 0.1%; R526
R527: 75R 0.1%; R527
R528: 75R 0.1%; R528; MPN TNPW080575R0BEEA
R529: 180R 1%; R529
R530: 37R4 1% 0.125W; R530
R531: 37R4 1% 0.125W; R531
R532: 37R4 1% 0.125W; R532
R533: 36.5k 0.1%; TNPW0805_Vishay_28950; MPN TNPW080536K5BEEA
R534: 3.83k 0.1%; TNPW0805_Vishay_28950; MPN TNPW08053K83BEEA
U43: THS7314D; THS7314D_D0008A; MPN THS7314D

Connections:
GND: C533.2, C534.2, C535.2, J500.2 (GND), J500.4 (GND), J500.6 (GND), J500.8 (GND), J500.10 (GND), J500.12 (GND), J500.14 (GND), J500.15 (GND), J500.16 (GND), R525.2, R526.2, R527.2, R530.2, R531.2, R532.2, R534.2, U43.2 (CH2_IN), U43.3 (CH3_IN), U43.5 (GND); also elsewhere on the board
SCART_AUD_L: J500.9 (SCART_AUD_L); also elsewhere on the board
SCART_AUD_R: J500.11 (SCART_AUD_R); also elsewhere on the board
SCART_B: J500.5 (SCART_B), R527.1; also elsewhere on the board
SCART_CSYNC: J500.7 (SCART_CSYNC), R528.2
SCART_G: J500.3 (SCART_G), R526.1; also elsewhere on the board
SCART_R: J500.1 (SCART_R), R525.1; also elsewhere on the board
SCART_RGB_SELECT: J500.13 (SCART_RGB_SELECT), R529.2
V3V3: C534.1, C535.1, U43.4 (VS+); also elsewhere on the board
V5: R529.1; also elsewhere on the board
VDAC_IOB_N: R530.1; also elsewhere on the board
VDAC_IOG_N: R531.1; also elsewhere on the board
VDAC_IOR_N: R532.1; also elsewhere on the board
VIDEO_CSYNC_AMP: R528.1, U43.8 (CH1_OUT)
VIDEO_CSYNC_BUF: R533.1; also elsewhere on the board
VIDEO_CSYNC_SCALED: C533.1, R533.2, R534.1, U43.1 (CH1_IN)

Notes on the sheet:
J500 is an internal polarized 2x8 harness, not a SCART socket footprint. Retained panel wiring below is for the console/source SCART socket.
J500 -> SCART: 1/2 -> 15/13 (R/return); 3/4 -> 11/9 (G/return); 5/6 -> 7/5 (B/return); 7/8 -> 19/17 (CSYNC/return).
9/10 -> 3/4 (audio L/return); 11/12 -> 1/4 (audio R/return); 13/14 -> 16/18 (RGB select/return); 15/16 -> 21/21 (screen/return).
SCART pin8 is unused; TV input is selected manually. No composite-video encoder. Use short shielded 75Ohm video leads; cable, ESD and EMC qualification remain open.
RGB outputs require local75Ohm shunts plus75Ohm TV loads. Complementary DAC loads remain37.4Ohm1%/0.125W; no connection or component-value changes in this ECO.

Schematic: clock_reset.kicad_sch, R9 clock fanout and beam reference

Parts:
C400: 100nF 16V X7R; C400
C401: 100nF 16V X7R; C401
C402: 100nF 16V X7R; C402
C403: 100nF 16V X7R; C403
R400: 22R; R400
R401: 22R; R401
R403: 22R; R403
R406: 22R; R406
R410: 22R; R410
U50: CDCLVC1108PW; U50
Y2: SG-8018CA 13.5000M-TJHPA0; Y2

Connections:
CLK_APU: R403.2; also elsewhere on the board
CLK_BEAM: R410.2; also elsewhere on the board
CLK_BEAM_OSC: R410.1, Y2.3 (OUT)
CLK_BUF_APU: R403.1, U50.15 (Y3)
CLK_BUF_CORE: R400.1, U50.3 (Y0)
CLK_BUF_GPU: R401.1, U50.16 (Y1)
CLK_BUF_IO: R406.1, U50.8 (Y6)
CLK_CORE: R400.2; also elsewhere on the board
CLK_GPU: R401.2; also elsewhere on the board
CLK_IO: R406.2; also elsewhere on the board
CLK_REF: U50.1 (CLKIN); also elsewhere on the board
GND: C400.2, C401.2, C402.2, C403.2, U50.4 (GND), U50.7 (GND), U50.12 (GND), Y2.2 (GND); also elsewhere on the board
V3V3: C400.1, C401.1, C402.1, C403.1, U50.2 (1G), U50.5 (VDD), U50.10 (VDD), U50.14 (VDD), Y2.1 (OE), Y2.4 (VCC); also elsewhere on the board

Notes on the sheet:
CDCLVC1108: four terminated SYS branches to CORE/GFX/APU/IO. Outputs Y2/Y4/Y5/Y7 are intentionally unconnected. 13.5MHz beam reference remains a separate GFX input. ASIC reset release must be locally synchronized.

Schematic: cartridge_buffer.kicad_sch, R9 cartridge data transceiver and reset inhibit

Parts:
C404: 100nF 16V X7R; C404
C405: 100nF 16V X7R; C405
C406: 100nF 16V X7R; C406
C407: 100nF 16V X7R; C407
C408: 100nF 16V X7R; C408
C409: 100nF 16V X7R; C409
R420: 4.7k; R420
R421: 10k; R421
U51: SN74LVC16245ADGGR; U51
U52: SN74LVC1G04DBVR; U52
U53: SN74LVC1G32DBVR; U53

Connections:
CAD0: U51.2 (1B1); also elsewhere on the board
CAD1: U51.3 (1B2); also elsewhere on the board
CAD2: U51.5 (1B3); also elsewhere on the board
CAD3: U51.6 (1B4); also elsewhere on the board
CAD4: U51.8 (1B5); also elsewhere on the board
CAD5: U51.9 (1B6); also elsewhere on the board
CAD6: U51.11 (1B7); also elsewhere on the board
CAD7: U51.12 (1B8); also elsewhere on the board
CAD8: U51.13 (2B1); also elsewhere on the board
CAD9: U51.14 (2B2); also elsewhere on the board
CAD10: U51.16 (2B3); also elsewhere on the board
CAD11: U51.17 (2B4); also elsewhere on the board
CAD12: U51.19 (2B5); also elsewhere on the board
CAD13: U51.20 (2B6); also elsewhere on the board
CAD14: U51.22 (2B7); also elsewhere on the board
CAD15: U51.23 (2B8); also elsewhere on the board
CART_BUFFER_OE_N: U51.25 (2OE_N), U51.48 (1OE_N), U53.4 (Y)
CART_DIR: R421.1, U51.1 (1DIR), U51.24 (2DIR); also elsewhere on the board
CART_OE_N: R420.2, U53.1 (A); also elsewhere on the board
CORE_CAD0: U51.47 (1A1); also elsewhere on the board
CORE_CAD1: U51.46 (1A2); also elsewhere on the board
CORE_CAD2: U51.44 (1A3); also elsewhere on the board
CORE_CAD3: U51.43 (1A4); also elsewhere on the board
CORE_CAD4: U51.41 (1A5); also elsewhere on the board
CORE_CAD5: U51.40 (1A6); also elsewhere on the board
CORE_CAD6: U51.38 (1A7); also elsewhere on the board
CORE_CAD7: U51.37 (1A8); also elsewhere on the board
CORE_CAD8: U51.36 (2A1); also elsewhere on the board
CORE_CAD9: U51.35 (2A2); also elsewhere on the board
CORE_CAD10: U51.33 (2A3); also elsewhere on the board
CORE_CAD11: U51.32 (2A4); also elsewhere on the board
CORE_CAD12: U51.30 (2A5); also elsewhere on the board
CORE_CAD13: U51.29 (2A6); also elsewhere on the board
CORE_CAD14: U51.27 (2A7); also elsewhere on the board
CORE_CAD15: U51.26 (2A8); also elsewhere on the board
GND: C404.2, C405.2, C406.2, C407.2, C408.2, C409.2, R421.2, U51.4 (GND), U51.10 (GND), U51.15 (GND), U51.21 (GND), U51.28 (GND), U51.34 (GND), U51.39 (GND), U51.45 (GND), U52.3 (GND), U53.3 (GND); also elsewhere on the board
RESET_ACTIVE: U52.4 (Y), U53.2 (B)
RESET_N: U52.2 (A); also elsewhere on the board
V3V3: C404.1, C405.1, C406.1, C407.1, C408.1, C409.1, R420.1, U51.7 (VCC), U51.18 (VCC), U51.31 (VCC), U51.42 (VCC), U52.5 (VCC), U53.5 (VCC); also elsewhere on the board

Notes on the sheet:
A=CORE_CAD; B=shared cartridge CAD. DIR=1 A-to-B, DIR=0 B-to-A. OE_N=U1.CART_OE_N OR NOT RESET_N.
No hotplug. Controller must disable OE before DIR changes and preserve the R7 full-word latch/commit contract.

Schematic: external_io.kicad_sch, Pad and PS/2 keyboard interfaces

Parts:
J300: B20B-PHDSS; JST_PHD_B20B-PHDSS_2x10_P2.00mm_Vertical; MPN B20B-PHDSS
J301: B4B-PH-K-S; JST_PH_B4B-PH-K_1x04_P2.00mm_Vertical; MPN B4B-PH-K-S
Q300: BSS138; Q300
Q301: BSS138; Q301
R430: 47R; R430
R431: 47R; R431
R432: 47R; R432
R433: 47R; R433
R434: 47R; R434
R435: 47R; R435
R436: 47R; R436
R437: 47R; R437
R438: 47R; R438
R439: 47R; R439
R440: 47R; R440
R441: 47R; R441
R442: 47R; R442
R450: 47k; R450
R451: 47k; R451
R452: 47k; R452
R453: 47k; R453
R460: 4.7k; R460
R461: 4.7k; R461
R462: 4.7k; R462
R463: 4.7k; R463

Connections:
GND: J300.16 (GND), J300.17 (GND), J300.18 (GND), J300.19 (GND), J300.20 (GND), J301.2 (GND); also elsewhere on the board
PAD_CLK: R430.1; also elsewhere on the board
PAD_CLK_EXT: J300.1 (PAD_CLK_EXT), R430.2
PAD_CMD0: R431.1; also elsewhere on the board
PAD_CMD0_EXT: J300.2 (PAD_CMD0_EXT), R431.2
PAD_CMD1: R432.1; also elsewhere on the board
PAD_CMD1_EXT: J300.3 (PAD_CMD1_EXT), R432.2
PAD_CMD2: R433.1; also elsewhere on the board
PAD_CMD2_EXT: J300.4 (PAD_CMD2_EXT), R433.2
PAD_CMD3: R434.1; also elsewhere on the board
PAD_CMD3_EXT: J300.5 (PAD_CMD3_EXT), R434.2
PAD_DATA0: R435.1, R450.2; also elsewhere on the board
PAD_DATA0_EXT: J300.6 (PAD_DATA0_EXT), R435.2
PAD_DATA1: R436.1, R451.2; also elsewhere on the board
PAD_DATA1_EXT: J300.7 (PAD_DATA1_EXT), R436.2
PAD_DATA2: R437.1, R452.2; also elsewhere on the board
PAD_DATA2_EXT: J300.8 (PAD_DATA2_EXT), R437.2
PAD_DATA3: R438.1, R453.2; also elsewhere on the board
PAD_DATA3_EXT: J300.9 (PAD_DATA3_EXT), R438.2
PAD_SELECT0_N: R439.1; also elsewhere on the board
PAD_SELECT0_N_EXT: J300.10 (PAD_SELECT0_N_EXT), R439.2
PAD_SELECT1_N: R440.1; also elsewhere on the board
PAD_SELECT1_N_EXT: J300.11 (PAD_SELECT1_N_EXT), R440.2
PAD_SELECT2_N: R441.1; also elsewhere on the board
PAD_SELECT2_N_EXT: J300.12 (PAD_SELECT2_N_EXT), R441.2
PAD_SELECT3_N: R442.1; also elsewhere on the board
PAD_SELECT3_N_EXT: J300.13 (PAD_SELECT3_N_EXT), R442.2
PS2_KBD_CLK: Q300.2 (S), R460.2; also elsewhere on the board
PS2_KBD_CLK_5V: J301.4 (CLK), Q300.3 (D), R461.2
PS2_KBD_DATA: Q301.2 (S), R462.2; also elsewhere on the board
PS2_KBD_DATA_5V: J301.1 (DATA), Q301.3 (D), R463.2
V3V3: J300.14 (V3V3), Q300.1 (G), Q301.1 (G), R450.1, R451.1, R452.1, R453.1, R460.1, R462.1; also elsewhere on the board
V5: J300.15 (V5), J301.3 (V5), R461.1, R463.1; also elsewhere on the board

Notes on the sheet:
Front harness uses the retained custom 9-contact pad sockets; no USB or SNES electrical compatibility.
BMSX-PAD v1: 250kHz, mode0, four parallel 64-byte frames; 3V3 push-pull DATA. Armed VBlank publishes held records. Pointer uses a pad socket; cable/ESD qualification remains open.

Schematic: jtag.kicad_sch, R9 JTAG daisy chain and service connector

Parts:
J302: BMSX JTAG service 2x5 - 3V3 reference only; J302
R470: 47k; R470
R471: 47k; R471
R473: 47k; R473
R476: 10k; R476

Connections:
GND: J302.2 (GND), J302.4 (GND), J302.10 (GND); also elsewhere on the board
JTAG_APU_IO: R473.2; also elsewhere on the board
JTAG_GFX_APU: R471.2; also elsewhere on the board
RESET_N: J302.9 (RESET_N); also elsewhere on the board
SUPERVISOR_N: R476.2; also elsewhere on the board
TCK: J302.3 (TCK); also elsewhere on the board
TDI: J302.6 (TDI); also elsewhere on the board
TDO: R470.2; also elsewhere on the board
TDO_RETURN: J302.7 (TDO_RETURN); also elsewhere on the board
TMS: J302.5 (TMS); also elsewhere on the board
TRST_N: J302.8 (TRST_N); also elsewhere on the board
V3V3: J302.1 (V3V3), R470.1, R471.1, R473.1, R476.1; also elsewhere on the board

Notes on the sheet:
Four TAP chain: connector TDI -> CORE -> GFX -> APU -> IO -> TDO_RETURN. 3V3 is voltage reference only, not an external power input. Real TAP/BSDL implementation and back-power qualification required.

Schematic: asic_decoupling_1.kicad_sch, R9 ASIC local bypass 1

Parts:
C300: 100nF 16V X7R; C300
C301: 100nF 16V X7R; C301
C302: 100nF 16V X7R; C302
C303: 100nF 16V X7R; C303
C304: 100nF 16V X7R; C304
C305: 100nF 16V X7R; C305
C306: 100nF 16V X7R; C306
C307: 100nF 16V X7R; C307
C308: 100nF 16V X7R; C308
C309: 100nF 16V X7R; C309
C310: 100nF 16V X7R; C310
C311: 100nF 16V X7R; C311
C312: 100nF 16V X7R; C312
C313: 100nF 16V X7R; C313
C314: 100nF 16V X7R; C314
C315: 100nF 16V X7R; C315
C316: 100nF 16V X7R; C316
C317: 100nF 16V X7R; C317
C318: 100nF 16V X7R; C318
C319: 4.7uF 16V X7R; C319
C320: 100nF 16V X7R; C320
C321: 100nF 16V X7R; C321
C322: 100nF 16V X7R; C322
C323: 100nF 16V X7R; C323
C324: 100nF 16V X7R; C324
C325: 100nF 16V X7R; C325
C326: 4.7uF 16V X7R; C326
C327: 100nF 16V X7R; C327
C328: 100nF 16V X7R; C328
C329: 100nF 16V X7R; C329
C330: 100nF 16V X7R; C330
C331: 100nF 16V X7R; C331
C332: 100nF 16V X7R; C332
C333: 100nF 16V X7R; C333
C334: 100nF 16V X7R; C334
C335: 100nF 16V X7R; C335
C336: 100nF 16V X7R; C336
C337: 100nF 16V X7R; C337
C338: 100nF 16V X7R; C338
C339: 100nF 16V X7R; C339
C340: 100nF 16V X7R; C340
C341: 100nF 16V X7R; C341

Connections:
GND: C300.2, C301.2, C302.2, C303.2, C304.2, C305.2, C306.2, C307.2, C308.2, C309.2, C310.2, C311.2, C312.2, C313.2, C314.2, C315.2, C316.2, C317.2, C318.2, C319.2, C320.2, C321.2, C322.2, C323.2, C324.2, C325.2, C326.2, C327.2, C328.2, C329.2, C330.2, C331.2, C332.2, C333.2, C334.2, C335.2, C336.2, C337.2, C338.2, C339.2, C340.2, C341.2; also elsewhere on the board
V3V3: C300.1, C301.1, C302.1, C303.1, C304.1, C305.1, C306.1, C307.1, C308.1, C309.1, C310.1, C311.1, C312.1, C313.1, C314.1, C315.1, C316.1, C317.1, C318.1, C319.1, C320.1, C321.1, C322.1, C323.1, C324.1, C325.1, C326.1, C327.1, C328.1, C329.1, C330.1, C331.1, C332.1, C333.1, C334.1, C335.1, C336.1, C337.1, C338.1, C339.1, C340.1, C341.1; also elsewhere on the board

Notes on the sheet:
Four-ASIC ECO bypass inventory: one 100nF per VDD pad and one 4.7uF bulk per package. Ownership labels refer to the new package pin numbers; placement and PDN qualification are separate.
Back-side placement under the package; PDN and current capability are not qualified.
U2: VDD pad 2
U2: VDD pad 11
U2: VDD pad 20
U2: VDD pad 29
U2: VDD pad 38
U2: VDD pad 52
U2: VDD pad 54
U2: VDD pad 63
U2: VDD pad 72
U2: VDD pad 81
U2: VDD pad 90
U2: VDD pad 104
U2: VDD pad 105
U2: VDD pad 119
U2: VDD pad 128
U2: VDD pad 137
U2: VDD pad 146
U2: VDD pad 155
U2: VDD pad 157
U2: package bulk
U1: VDD pad 72
U1: VDD pad 81
U1: VDD pad 90
U1: VDD pad 104
U1: VDD pad 105
U1: VDD pad 119
U1: package bulk
U4: VDD pad 2
U4: VDD pad 10
U4: VDD pad 18
U4: VDD pad 38
U4: VDD pad 40
U4: VDD pad 48
U4: VDD pad 56
U4: VDD pad 64
U4: VDD pad 65
U4: VDD pad 85
U4: VDD pad 93

Schematic: asic_decoupling_2.kicad_sch, R9 ASIC local bypass 2

Parts:
C342: 100nF 16V X7R; C342
C343: 4.7uF 16V X7R; C343
C344: 100nF 16V X7R; C344
C345: 100nF 16V X7R; C345
C346: 100nF 16V X7R; C346
C347: 100nF 16V X7R; C347
C348: 100nF 16V X7R; C348
C349: 100nF 16V X7R; C349
C350: 100nF 16V X7R; C350
C351: 100nF 16V X7R; C351
C352: 100nF 16V X7R; C352
C364: 100nF 16V X7R; C364
C365: 100nF 16V X7R; C365
C366: 100nF 16V X7R; C366
C367: 100nF 16V X7R; C367
C368: 100nF 16V X7R; C368
C369: 100nF 16V X7R; C369
C371: 100nF 16V X7R; C371
C372: 100nF 16V X7R; C372
C373: 100nF 16V X7R; C373
C374: 100nF 16V X7R; C374
C375: 100nF 16V X7R; C375
C376: 100nF 16V X7R; C376
C377: 100nF 16V X7R; C377
C378: 100nF 16V X7R; C378
C379: 100nF 16V X7R; C379
C380: 100nF 16V X7R; C380
C381: 4.7uF 16V X7R; C381

Connections:
GND: C342.2, C343.2, C344.2, C345.2, C346.2, C347.2, C348.2, C349.2, C350.2, C351.2, C352.2, C364.2, C365.2, C366.2, C367.2, C368.2, C369.2, C371.2, C372.2, C373.2, C374.2, C375.2, C376.2, C377.2, C378.2, C379.2, C380.2, C381.2; also elsewhere on the board
V3V3: C342.1, C343.1, C344.1, C345.1, C346.1, C347.1, C348.1, C349.1, C350.1, C351.1, C352.1, C364.1, C365.1, C366.1, C367.1, C368.1, C369.1, C371.1, C372.1, C373.1, C374.1, C375.1, C376.1, C377.1, C378.1, C379.1, C380.1, C381.1; also elsewhere on the board

Notes on the sheet:
Four-ASIC ECO bypass inventory: one 100nF per VDD pad and one 4.7uF bulk per package. Ownership labels refer to the new package pin numbers; placement and PDN qualification are separate.
Back-side placement under the package; PDN and current capability are not qualified.
U4: VDD pad 127
U4: package bulk
U1: VDD pad 180
U1: VDD pad 189
U1: VDD pad 198
U1: VDD pad 207
U2: VDD pad 171
U2: VDD pad 180
U2: VDD pad 189
U2: VDD pad 198
U2: VDD pad 207
U1: VDD pad 128
U1: VDD pad 137
U1: VDD pad 146
U1: VDD pad 155
U1: VDD pad 157
U1: VDD pad 171
U7: VDD pad 2
U7: VDD pad 20
U7: VDD pad 38
U7: VDD pad 40
U7: VDD pad 64
U7: VDD pad 65
U7: VDD pad 83
U7: VDD pad 101
U7: VDD pad 103
U7: VDD pad 127
U7: package bulk

Schematic: asic_u1.kicad_sch, BMSX CORE: CPU + GTE + DMA + GEO + IMGDEC

Parts:
U1: BMSX CORE: CPU + GTE + DMA + GEO + IMGDEC; U1

Connections:
CAL_HI: U1.75 (CAL_HI); also elsewhere on the board
CAL_LO: U1.76 (CAL_LO); also elsewhere on the board
CART_CLK: U1.77 (CART_CLK); also elsewhere on the board
CART_DIR: U1.78 (CART_DIR); also elsewhere on the board
CART_OE_N: U1.79 (CART_OE_N); also elsewhere on the board
CART_PRESENT0_N: U1.82 (CART_PRESENT0_N); also elsewhere on the board
CART_PRESENT1_N: U1.83 (CART_PRESENT1_N); also elsewhere on the board
CART_READY0_N: U1.84 (CART_READY0_N); also elsewhere on the board
CART_READY1_N: U1.85 (CART_READY1_N); also elsewhere on the board
CART_RESET_N: U1.86 (CART_RESET_N); also elsewhere on the board
CBE0_N: U1.87 (CBE0_N); also elsewhere on the board
CBE1_N: U1.88 (CBE1_N); also elsewhere on the board
CLK_CORE: U1.206 (CLK_SYS); also elsewhere on the board
CORE_CAD0: U1.55 (CAD0); also elsewhere on the board
CORE_CAD1: U1.56 (CAD1); also elsewhere on the board
CORE_CAD2: U1.57 (CAD2); also elsewhere on the board
CORE_CAD3: U1.58 (CAD3); also elsewhere on the board
CORE_CAD4: U1.59 (CAD4); also elsewhere on the board
CORE_CAD5: U1.60 (CAD5); also elsewhere on the board
CORE_CAD6: U1.61 (CAD6); also elsewhere on the board
CORE_CAD7: U1.64 (CAD7); also elsewhere on the board
CORE_CAD8: U1.65 (CAD8); also elsewhere on the board
CORE_CAD9: U1.66 (CAD9); also elsewhere on the board
CORE_CAD10: U1.67 (CAD10); also elsewhere on the board
CORE_CAD11: U1.68 (CAD11); also elsewhere on the board
CORE_CAD12: U1.69 (CAD12); also elsewhere on the board
CORE_CAD13: U1.70 (CAD13); also elsewhere on the board
CORE_CAD14: U1.73 (CAD14); also elsewhere on the board
CORE_CAD15: U1.74 (CAD15); also elsewhere on the board
CRD_N: U1.91 (CRD_N); also elsewhere on the board
CS_APU_N: U1.205 (CS_APU_N); also elsewhere on the board
CS_CART0_N: U1.92 (CS_CART0_N); also elsewhere on the board
CS_CART1_N: U1.93 (CS_CART1_N); also elsewhere on the board
CS_GPU_N: U1.204 (CS_GPU_N); also elsewhere on the board
CS_IO_N: U1.203 (CS_IO_N); also elsewhere on the board
CS_PCRTC_N: U1.202 (CS_PCRTC_N); also elsewhere on the board
CS_ROM_N: U1.201 (CS_ROM_N); also elsewhere on the board
CWR_N: U1.94 (CWR_N); also elsewhere on the board
DREQ_APU_R: U1.200 (DREQ_APU_R); also elsewhere on the board
DREQ_APU_W: U1.197 (DREQ_APU_W); also elsewhere on the board
DREQ_C0_R: U1.95 (DREQ_C0_R); also elsewhere on the board
DREQ_C0_W: U1.96 (DREQ_C0_W); also elsewhere on the board
DREQ_C1_R: U1.97 (DREQ_C1_R); also elsewhere on the board
DREQ_C1_W: U1.98 (DREQ_C1_W); also elsewhere on the board
DREQ_GPU_R: U1.196 (DREQ_GPU_R); also elsewhere on the board
DREQ_GPU_W: U1.195 (DREQ_GPU_W); also elsewhere on the board
GND: U1.1 (GND), U1.10 (GND), U1.19 (GND), U1.28 (GND), U1.37 (GND), U1.51 (GND), U1.53 (GND), U1.62 (GND), U1.71 (GND), U1.80 (GND), U1.89 (GND), U1.103 (GND), U1.106 (GND), U1.120 (GND), U1.129 (GND), U1.138 (GND), U1.147 (GND), U1.156 (GND), U1.158 (GND), U1.172 (GND), U1.181 (GND), U1.190 (GND), U1.199 (GND), U1.208 (GND); also elsewhere on the board
GNT_APU: U1.194 (GNT_APU); also elsewhere on the board
IRQ_APU_N: U1.193 (IRQ_APU_N); also elsewhere on the board
IRQ_CART0_N: U1.99 (IRQ_CART0_N); also elsewhere on the board
IRQ_CART1_N: U1.100 (IRQ_CART1_N); also elsewhere on the board
IRQ_GPU_N: U1.192 (IRQ_GPU_N); also elsewhere on the board
IRQ_PCRTC_N: U1.191 (IRQ_PCRTC_N); also elsewhere on the board
MA0: U1.188 (MA0); also elsewhere on the board
MA1: U1.187 (MA1); also elsewhere on the board
MA2: U1.186 (MA2); also elsewhere on the board
MA3: U1.185 (MA3); also elsewhere on the board
MA4: U1.184 (MA4); also elsewhere on the board
MA5: U1.183 (MA5); also elsewhere on the board
MA6: U1.182 (MA6); also elsewhere on the board
MA7: U1.179 (MA7); also elsewhere on the board
MA8: U1.178 (MA8); also elsewhere on the board
MA9: U1.177 (MA9); also elsewhere on the board
MCAS0_N: U1.44 (MCAS0_N); also elsewhere on the board
MCAS1_N: U1.45 (MCAS1_N); also elsewhere on the board
MCAS2_N: U1.46 (MCAS2_N); also elsewhere on the board
MCAS3_N: U1.47 (MCAS3_N); also elsewhere on the board
MD0: U1.3 (MD0); also elsewhere on the board
MD1: U1.4 (MD1); also elsewhere on the board
MD2: U1.5 (MD2); also elsewhere on the board
MD3: U1.6 (MD3); also elsewhere on the board
MD4: U1.7 (MD4); also elsewhere on the board
MD5: U1.8 (MD5); also elsewhere on the board
MD6: U1.9 (MD6); also elsewhere on the board
MD7: U1.12 (MD7); also elsewhere on the board
MD8: U1.13 (MD8); also elsewhere on the board
MD9: U1.14 (MD9); also elsewhere on the board
MD10: U1.15 (MD10); also elsewhere on the board
MD11: U1.16 (MD11); also elsewhere on the board
MD12: U1.17 (MD12); also elsewhere on the board
MD13: U1.18 (MD13); also elsewhere on the board
MD14: U1.21 (MD14); also elsewhere on the board
MD15: U1.22 (MD15); also elsewhere on the board
MD16: U1.23 (MD16); also elsewhere on the board
MD17: U1.24 (MD17); also elsewhere on the board
MD18: U1.25 (MD18); also elsewhere on the board
MD19: U1.26 (MD19); also elsewhere on the board
MD20: U1.27 (MD20); also elsewhere on the board
MD21: U1.30 (MD21); also elsewhere on the board
MD22: U1.31 (MD22); also elsewhere on the board
MD23: U1.32 (MD23); also elsewhere on the board
MD24: U1.33 (MD24); also elsewhere on the board
MD25: U1.34 (MD25); also elsewhere on the board
MD26: U1.35 (MD26); also elsewhere on the board
MD27: U1.36 (MD27); also elsewhere on the board
MD28: U1.39 (MD28); also elsewhere on the board
MD29: U1.40 (MD29); also elsewhere on the board
MD30: U1.41 (MD30); also elsewhere on the board
MD31: U1.42 (MD31); also elsewhere on the board
MOE_N: U1.49 (MOE_N); also elsewhere on the board
MOE_PRIVATE_N: U1.101 (MOE_PRIVATE_N); also elsewhere on the board
MRAS_N: U1.43 (MRAS_N); also elsewhere on the board
MRAS_PRIVATE_N: U1.50 (MRAS_PRIVATE_N); also elsewhere on the board
MWE_N: U1.48 (MWE_N); also elsewhere on the board
REQ_APU: U1.176 (REQ_APU); also elsewhere on the board
RESET_N: U1.175 (RESET_N); also elsewhere on the board
SUPERVISOR_N: U1.174 (SUPERVISOR_N); also elsewhere on the board
SYS_AD0: U1.154 (SYS_AD0); also elsewhere on the board
SYS_AD1: U1.153 (SYS_AD1); also elsewhere on the board
SYS_AD2: U1.152 (SYS_AD2); also elsewhere on the board
SYS_AD3: U1.151 (SYS_AD3); also elsewhere on the board
SYS_AD4: U1.150 (SYS_AD4); also elsewhere on the board
SYS_AD5: U1.149 (SYS_AD5); also elsewhere on the board
SYS_AD6: U1.148 (SYS_AD6); also elsewhere on the board
SYS_AD7: U1.145 (SYS_AD7); also elsewhere on the board
SYS_AD8: U1.144 (SYS_AD8); also elsewhere on the board
SYS_AD9: U1.143 (SYS_AD9); also elsewhere on the board
SYS_AD10: U1.142 (SYS_AD10); also elsewhere on the board
SYS_AD11: U1.141 (SYS_AD11); also elsewhere on the board
SYS_AD12: U1.140 (SYS_AD12); also elsewhere on the board
SYS_AD13: U1.139 (SYS_AD13); also elsewhere on the board
SYS_AD14: U1.136 (SYS_AD14); also elsewhere on the board
SYS_AD15: U1.135 (SYS_AD15); also elsewhere on the board
SYS_AD16: U1.134 (SYS_AD16); also elsewhere on the board
SYS_AD17: U1.133 (SYS_AD17); also elsewhere on the board
SYS_AD18: U1.132 (SYS_AD18); also elsewhere on the board
SYS_AD19: U1.131 (SYS_AD19); also elsewhere on the board
SYS_AD20: U1.130 (SYS_AD20); also elsewhere on the board
SYS_AD21: U1.127 (SYS_AD21); also elsewhere on the board
SYS_AD22: U1.126 (SYS_AD22); also elsewhere on the board
SYS_AD23: U1.125 (SYS_AD23); also elsewhere on the board
SYS_AD24: U1.124 (SYS_AD24); also elsewhere on the board
SYS_AD25: U1.123 (SYS_AD25); also elsewhere on the board
SYS_AD26: U1.122 (SYS_AD26); also elsewhere on the board
SYS_AD27: U1.121 (SYS_AD27); also elsewhere on the board
SYS_AD28: U1.118 (SYS_AD28); also elsewhere on the board
SYS_AD29: U1.117 (SYS_AD29); also elsewhere on the board
SYS_AD30: U1.116 (SYS_AD30); also elsewhere on the board
SYS_AD31: U1.115 (SYS_AD31); also elsewhere on the board
SYS_AS_N: U1.114 (SYS_AS_N); also elsewhere on the board
SYS_BE0_N: U1.111 (SYS_BE0_N); also elsewhere on the board
SYS_BE1_N: U1.110 (SYS_BE1_N); also elsewhere on the board
SYS_BE2_N: U1.109 (SYS_BE2_N); also elsewhere on the board
SYS_BE3_N: U1.108 (SYS_BE3_N); also elsewhere on the board
SYS_RD_N: U1.113 (SYS_RD_N); also elsewhere on the board
SYS_READY_N: U1.107 (SYS_READY_N); also elsewhere on the board
SYS_WR_N: U1.112 (SYS_WR_N); also elsewhere on the board
TCK: U1.173 (TCK); also elsewhere on the board
TDI: U1.170 (TDI); also elsewhere on the board
TDO: U1.169 (TDO); also elsewhere on the board
TESTMODE: U1.168 (TESTMODE); also elsewhere on the board
TMS: U1.167 (TMS); also elsewhere on the board
TRST_N: U1.166 (TRST_N); also elsewhere on the board
V3V3: U1.2 (VDD), U1.11 (VDD), U1.20 (VDD), U1.29 (VDD), U1.38 (VDD), U1.52 (VDD), U1.54 (VDD), U1.63 (VDD), U1.72 (VDD), U1.81 (VDD), U1.90 (VDD), U1.104 (VDD), U1.105 (VDD), U1.119 (VDD), U1.128 (VDD), U1.137 (VDD), U1.146 (VDD), U1.155 (VDD), U1.157 (VDD), U1.171 (VDD), U1.180 (VDD), U1.189 (VDD), U1.198 (VDD), U1.207 (VDD); also elsewhere on the board
VBLANK_EVT: U1.165 (VBLANK_EVT); also elsewhere on the board

Notes on the sheet:
Four-package ECO. External signal directions retained; GEO/IMGDEC and GPU/PCRTC links are internalized. SYS32 remains multicycle. Package power and TAP require ASIC implementation and BSDL qualification.
POWER
MAIN DRAM
CONTROL AND TAP
CARTRIDGE
SYS32

Schematic: asic_u2.kicad_sch, BMSX GFX: GPU + PCRTC

Parts:
U2: BMSX GFX: GPU + PCRTC; U2

Connections:
CLK_BEAM: U2.193 (CLK_BEAM); also elsewhere on the board
CLK_GPU: U2.192 (CLK_SYS); also elsewhere on the board
CS_GPU_N: U2.55 (CS_GPU_N); also elsewhere on the board
CS_PCRTC_N: U2.56 (CS_PCRTC_N); also elsewhere on the board
DISPLAY_CONTEXT: U2.174 (DISPLAY_CONTEXT); also elsewhere on the board
DREQ_GPU_R: U2.57 (DREQ_GPU_R); also elsewhere on the board
DREQ_GPU_W: U2.58 (DREQ_GPU_W); also elsewhere on the board
GND: U2.1 (GND), U2.10 (GND), U2.19 (GND), U2.28 (GND), U2.37 (GND), U2.51 (GND), U2.53 (GND), U2.62 (GND), U2.71 (GND), U2.80 (GND), U2.89 (GND), U2.103 (GND), U2.106 (GND), U2.120 (GND), U2.129 (GND), U2.138 (GND), U2.147 (GND), U2.156 (GND), U2.158 (GND), U2.172 (GND), U2.181 (GND), U2.190 (GND), U2.199 (GND), U2.208 (GND); also elsewhere on the board
IRQ_GPU_N: U2.59 (IRQ_GPU_N); also elsewhere on the board
IRQ_PCRTC_N: U2.60 (IRQ_PCRTC_N); also elsewhere on the board
JTAG_GFX_APU: U2.191 (TDO); also elsewhere on the board
RESET_N: U2.188 (RESET_N); also elsewhere on the board
RGB_B0: U2.61 (RGB_B0); also elsewhere on the board
RGB_B1: U2.64 (RGB_B1); also elsewhere on the board
RGB_B2: U2.65 (RGB_B2); also elsewhere on the board
RGB_B3: U2.66 (RGB_B3); also elsewhere on the board
RGB_B4: U2.67 (RGB_B4); also elsewhere on the board
RGB_B5: U2.68 (RGB_B5); also elsewhere on the board
RGB_B6: U2.69 (RGB_B6); also elsewhere on the board
RGB_B7: U2.70 (RGB_B7); also elsewhere on the board
RGB_G0: U2.73 (RGB_G0); also elsewhere on the board
RGB_G1: U2.74 (RGB_G1); also elsewhere on the board
RGB_G2: U2.75 (RGB_G2); also elsewhere on the board
RGB_G3: U2.76 (RGB_G3); also elsewhere on the board
RGB_G4: U2.77 (RGB_G4); also elsewhere on the board
RGB_G5: U2.78 (RGB_G5); also elsewhere on the board
RGB_G6: U2.79 (RGB_G6); also elsewhere on the board
RGB_G7: U2.82 (RGB_G7); also elsewhere on the board
RGB_R0: U2.83 (RGB_R0); also elsewhere on the board
RGB_R1: U2.84 (RGB_R1); also elsewhere on the board
RGB_R2: U2.85 (RGB_R2); also elsewhere on the board
RGB_R3: U2.86 (RGB_R3); also elsewhere on the board
RGB_R4: U2.87 (RGB_R4); also elsewhere on the board
RGB_R5: U2.88 (RGB_R5); also elsewhere on the board
RGB_R6: U2.91 (RGB_R6); also elsewhere on the board
RGB_R7: U2.92 (RGB_R7); also elsewhere on the board
SNAPSHOT_CE_N: U2.102 (SNAPSHOT_CE_N); also elsewhere on the board
SYS_AD0: U2.3 (SYS_AD0); also elsewhere on the board
SYS_AD1: U2.4 (SYS_AD1); also elsewhere on the board
SYS_AD2: U2.5 (SYS_AD2); also elsewhere on the board
SYS_AD3: U2.6 (SYS_AD3); also elsewhere on the board
SYS_AD4: U2.7 (SYS_AD4); also elsewhere on the board
SYS_AD5: U2.8 (SYS_AD5); also elsewhere on the board
SYS_AD6: U2.9 (SYS_AD6); also elsewhere on the board
SYS_AD7: U2.12 (SYS_AD7); also elsewhere on the board
SYS_AD8: U2.13 (SYS_AD8); also elsewhere on the board
SYS_AD9: U2.14 (SYS_AD9); also elsewhere on the board
SYS_AD10: U2.15 (SYS_AD10); also elsewhere on the board
SYS_AD11: U2.16 (SYS_AD11); also elsewhere on the board
SYS_AD12: U2.17 (SYS_AD12); also elsewhere on the board
SYS_AD13: U2.18 (SYS_AD13); also elsewhere on the board
SYS_AD14: U2.21 (SYS_AD14); also elsewhere on the board
SYS_AD15: U2.22 (SYS_AD15); also elsewhere on the board
SYS_AD16: U2.23 (SYS_AD16); also elsewhere on the board
SYS_AD17: U2.24 (SYS_AD17); also elsewhere on the board
SYS_AD18: U2.25 (SYS_AD18); also elsewhere on the board
SYS_AD19: U2.26 (SYS_AD19); also elsewhere on the board
SYS_AD20: U2.27 (SYS_AD20); also elsewhere on the board
SYS_AD21: U2.30 (SYS_AD21); also elsewhere on the board
SYS_AD22: U2.31 (SYS_AD22); also elsewhere on the board
SYS_AD23: U2.32 (SYS_AD23); also elsewhere on the board
SYS_AD24: U2.33 (SYS_AD24); also elsewhere on the board
SYS_AD25: U2.34 (SYS_AD25); also elsewhere on the board
SYS_AD26: U2.35 (SYS_AD26); also elsewhere on the board
SYS_AD27: U2.36 (SYS_AD27); also elsewhere on the board
SYS_AD28: U2.39 (SYS_AD28); also elsewhere on the board
SYS_AD29: U2.40 (SYS_AD29); also elsewhere on the board
SYS_AD30: U2.41 (SYS_AD30); also elsewhere on the board
SYS_AD31: U2.42 (SYS_AD31); also elsewhere on the board
SYS_AS_N: U2.43 (SYS_AS_N); also elsewhere on the board
SYS_BE0_N: U2.46 (SYS_BE0_N); also elsewhere on the board
SYS_BE1_N: U2.47 (SYS_BE1_N); also elsewhere on the board
SYS_BE2_N: U2.48 (SYS_BE2_N); also elsewhere on the board
SYS_BE3_N: U2.49 (SYS_BE3_N); also elsewhere on the board
SYS_RD_N: U2.44 (SYS_RD_N); also elsewhere on the board
SYS_READY_N: U2.50 (SYS_READY_N); also elsewhere on the board
SYS_WR_N: U2.45 (SYS_WR_N); also elsewhere on the board
TCK: U2.187 (TCK); also elsewhere on the board
TDO: U2.186 (TDI); also elsewhere on the board
TMS: U2.185 (TMS); also elsewhere on the board
TRST_N: U2.184 (TRST_N); also elsewhere on the board
V3V3: U2.2 (VDD), U2.11 (VDD), U2.20 (VDD), U2.29 (VDD), U2.38 (VDD), U2.52 (VDD), U2.54 (VDD), U2.63 (VDD), U2.72 (VDD), U2.81 (VDD), U2.90 (VDD), U2.104 (VDD), U2.105 (VDD), U2.119 (VDD), U2.128 (VDD), U2.137 (VDD), U2.146 (VDD), U2.155 (VDD), U2.157 (VDD), U2.171 (VDD), U2.180 (VDD), U2.189 (VDD), U2.198 (VDD), U2.207 (VDD); also elsewhere on the board
VBLANK_EVT: U2.93 (VBLANK_EVT); also elsewhere on the board
VIDEO_BLANK_N: U2.94 (VIDEO_BLANK_N); also elsewhere on the board
VIDEO_CSYNC_N: U2.95 (VIDEO_CSYNC_N); also elsewhere on the board
VIDEO_PCLK: U2.96 (VIDEO_PCLK); also elsewhere on the board
VRAM_A0: U2.114 (VRAM_A0); also elsewhere on the board
VRAM_A1: U2.113 (VRAM_A1); also elsewhere on the board
VRAM_A2: U2.112 (VRAM_A2); also elsewhere on the board
VRAM_A3: U2.111 (VRAM_A3); also elsewhere on the board
VRAM_A4: U2.110 (VRAM_A4); also elsewhere on the board
VRAM_A5: U2.109 (VRAM_A5); also elsewhere on the board
VRAM_A6: U2.108 (VRAM_A6); also elsewhere on the board
VRAM_A7: U2.107 (VRAM_A7); also elsewhere on the board
VRAM_A8: U2.206 (VRAM_A8); also elsewhere on the board
VRAM_A9: U2.205 (VRAM_A9); also elsewhere on the board
VRAM_A10: U2.204 (VRAM_A10); also elsewhere on the board
VRAM_A11: U2.203 (VRAM_A11); also elsewhere on the board
VRAM_A12: U2.202 (VRAM_A12); also elsewhere on the board
VRAM_A13: U2.201 (VRAM_A13); also elsewhere on the board
VRAM_A14: U2.200 (VRAM_A14); also elsewhere on the board
VRAM_A15: U2.197 (VRAM_A15); also elsewhere on the board
VRAM_A16: U2.196 (VRAM_A16); also elsewhere on the board
VRAM_A17: U2.195 (VRAM_A17); also elsewhere on the board
VRAM_A18: U2.194 (VRAM_A18); also elsewhere on the board
VRAM_BE0_N: U2.183 (VRAM_BE0_N); also elsewhere on the board
VRAM_BE1_N: U2.182 (VRAM_BE1_N); also elsewhere on the board
VRAM_BE2_N: U2.179 (VRAM_BE2_N); also elsewhere on the board
VRAM_BE3_N: U2.178 (VRAM_BE3_N); also elsewhere on the board
VRAM_CE_N: U2.177 (VRAM_CE_N); also elsewhere on the board
VRAM_D0: U2.154 (VRAM_D0); also elsewhere on the board
VRAM_D1: U2.153 (VRAM_D1); also elsewhere on the board
VRAM_D2: U2.152 (VRAM_D2); also elsewhere on the board
VRAM_D3: U2.151 (VRAM_D3); also elsewhere on the board
VRAM_D4: U2.150 (VRAM_D4); also elsewhere on the board
VRAM_D5: U2.149 (VRAM_D5); also elsewhere on the board
VRAM_D6: U2.148 (VRAM_D6); also elsewhere on the board
VRAM_D7: U2.145 (VRAM_D7); also elsewhere on the board
VRAM_D8: U2.144 (VRAM_D8); also elsewhere on the board
VRAM_D9: U2.143 (VRAM_D9); also elsewhere on the board
VRAM_D10: U2.142 (VRAM_D10); also elsewhere on the board
VRAM_D11: U2.141 (VRAM_D11); also elsewhere on the board
VRAM_D12: U2.140 (VRAM_D12); also elsewhere on the board
VRAM_D13: U2.139 (VRAM_D13); also elsewhere on the board
VRAM_D14: U2.136 (VRAM_D14); also elsewhere on the board
VRAM_D15: U2.135 (VRAM_D15); also elsewhere on the board
VRAM_D16: U2.134 (VRAM_D16); also elsewhere on the board
VRAM_D17: U2.133 (VRAM_D17); also elsewhere on the board
VRAM_D18: U2.132 (VRAM_D18); also elsewhere on the board
VRAM_D19: U2.131 (VRAM_D19); also elsewhere on the board
VRAM_D20: U2.130 (VRAM_D20); also elsewhere on the board
VRAM_D21: U2.127 (VRAM_D21); also elsewhere on the board
VRAM_D22: U2.126 (VRAM_D22); also elsewhere on the board
VRAM_D23: U2.125 (VRAM_D23); also elsewhere on the board
VRAM_D24: U2.124 (VRAM_D24); also elsewhere on the board
VRAM_D25: U2.123 (VRAM_D25); also elsewhere on the board
VRAM_D26: U2.122 (VRAM_D26); also elsewhere on the board
VRAM_D27: U2.121 (VRAM_D27); also elsewhere on the board
VRAM_D28: U2.118 (VRAM_D28); also elsewhere on the board
VRAM_D29: U2.117 (VRAM_D29); also elsewhere on the board
VRAM_D30: U2.116 (VRAM_D30); also elsewhere on the board
VRAM_D31: U2.115 (VRAM_D31); also elsewhere on the board
VRAM_OE_N: U2.176 (VRAM_OE_N); also elsewhere on the board
VRAM_WE_N: U2.175 (VRAM_WE_N); also elsewhere on the board

Notes on the sheet:
Four-package ECO. External signal directions retained; GEO/IMGDEC and GPU/PCRTC links are internalized. SYS32 remains multicycle. Package power and TAP require ASIC implementation and BSDL qualification.
POWER
SYS32
CONTROL AND TAP
VIDEO OUTPUT
VIDEO SRAM
